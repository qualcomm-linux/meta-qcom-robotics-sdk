
INSANE_SKIP:${PN} += "installed-vs-shipped"
FILES:${PN} = ""


ALLOW_EMPTY:${PN} = "1"
