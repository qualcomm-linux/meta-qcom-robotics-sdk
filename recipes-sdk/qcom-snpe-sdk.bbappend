
INSANE_SKIP:${PN} += "installed-vs-shipped"

FILES:${PN} = ""
FILES:${PN}-dev = ""

ALLOW_EMPTY:${PN} = "1"
ALLOW_EMPTY:${PN}-dev = "1"
