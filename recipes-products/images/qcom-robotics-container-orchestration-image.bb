# Copyright (c) 2025 Qualcomm Innovation Center, Inc. All rights reserved.
# SPDX-License-Identifier: BSD-3-Clause-Clear

require recipes-products/images/qcom-container-orchestration-image.bb
require qcom-robotics-proprietary-image.bb