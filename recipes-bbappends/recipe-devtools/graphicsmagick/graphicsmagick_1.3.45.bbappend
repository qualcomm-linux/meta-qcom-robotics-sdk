SRC_URI = " \
            https://sourceforge.net/projects/graphicsmagick/files/graphicsmagick/${PV}/GraphicsMagick-${PV}.tar.xz \
            file://remove-host-build-info-from-version-command.patch"

SRC_URI[sha256sum] = "dcea5167414f7c805557de2d7a47a9b3147bcbf617b91f5f0f4afe5e6543026b"
