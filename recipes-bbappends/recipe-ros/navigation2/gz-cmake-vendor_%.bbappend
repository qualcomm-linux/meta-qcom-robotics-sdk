DEPENDS:append = " python3-vcstool-native python3-setuptools-native"

