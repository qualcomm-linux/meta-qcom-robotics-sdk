# |   Could not find a package configuration file provided by
# |   "rosidl_core_generators" with any of the following names:
# |
# |     rosidl_core_generatorsConfig.cmake
# |     rosidl_core_generators-config.cmake   
ROS_BUILDTOOL_DEPENDS = " \
    rosidl-default-generators-native \
"
