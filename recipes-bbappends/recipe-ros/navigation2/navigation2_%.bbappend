ROS_EXEC_DEPENDS:remove = " \
    nav2-rviz-plugins \
    nav2-mppi-controller \
    nav2-smac-planner \
"
