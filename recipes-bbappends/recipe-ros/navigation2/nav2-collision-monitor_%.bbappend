CXXFLAGS += "-Wno-error=deprecated-declarations -Wno-error=non-virtual-dtor -Wno-error=shadow -Wno-error=overloaded-virtual="
