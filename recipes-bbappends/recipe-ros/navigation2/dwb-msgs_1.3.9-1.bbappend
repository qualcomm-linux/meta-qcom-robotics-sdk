
ROS_BUILDTOOL_DEPENDS = " \
    rosidl-default-generators-native \
"
