FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI:remove = "file://0001-disable-compiler-warnings.patch"
