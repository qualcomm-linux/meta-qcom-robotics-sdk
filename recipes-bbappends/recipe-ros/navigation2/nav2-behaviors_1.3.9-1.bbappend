CXXFLAGS += "-Wno-error=deprecated-declarations -Wno-error=null-dereference -Wno-error=free-nonheap-object -Wno-error=non-virtual-dtor -Wno-error=shadow"
