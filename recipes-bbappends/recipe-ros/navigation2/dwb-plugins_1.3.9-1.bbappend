CXXFLAGS += "-Wno-error=shadow -Wno-error=non-virtual-dtor -Wno-error=deprecated-declarations"
