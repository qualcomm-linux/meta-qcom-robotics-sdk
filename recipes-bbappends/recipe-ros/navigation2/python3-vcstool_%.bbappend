FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Replace-pkg_resources-with-importlib.metadata.patch"

