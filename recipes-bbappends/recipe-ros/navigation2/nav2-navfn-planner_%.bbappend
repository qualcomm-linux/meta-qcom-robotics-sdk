CXXFLAGS += "-Wno-error=deprecated-declarations -Wno-error=shadow -Wno-error=non-virtual-dtor -Wno-error=unused-but-set-variable"
