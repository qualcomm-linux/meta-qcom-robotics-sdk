
CXXFLAGS += "-Wno-error=shadow -Wno-error=deprecated-declarations "
