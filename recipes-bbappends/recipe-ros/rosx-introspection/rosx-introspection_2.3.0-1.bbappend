do_configure[network] = "1"
