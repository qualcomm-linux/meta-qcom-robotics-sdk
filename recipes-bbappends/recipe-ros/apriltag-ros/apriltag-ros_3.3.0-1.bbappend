CXXFLAGS:append = " -Wno-error=deprecated-declarations"

RDEPENDS:${PN}:remove = "camera-ros"
