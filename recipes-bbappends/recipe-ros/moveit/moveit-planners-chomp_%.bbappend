inherit ros_insane_dev_so