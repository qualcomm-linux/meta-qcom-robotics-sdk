# tl-expected 1.3.1 is a header-only library; the main package installs no binaries.
ALLOW_EMPTY:${PN} = "1"
