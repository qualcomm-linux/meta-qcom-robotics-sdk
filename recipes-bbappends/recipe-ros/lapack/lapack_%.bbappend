# Missing or unbuildable dependency chain was: ['navigation2', 'nav2-constrained-smoother', 
# 'ceres-solver', 'suitesparse-cholmod', 'openblas']
# refer to https://github.com/ros/meta-ros/commit/7caf1f1a9a65bf1d83df37f8c4cbf932f8b304e8#diff-348ad19a1e3362acb475fa953dfbe57e365ca7a617bfcfeb7c573e6a8824ce9d
PROVIDES += "openblas"
