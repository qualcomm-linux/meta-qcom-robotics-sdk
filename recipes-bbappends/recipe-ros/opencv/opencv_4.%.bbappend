# required by qrb-ros-tensor-process/qrb-yolo-process-lib
PACKAGECONFIG:append = " dnn"