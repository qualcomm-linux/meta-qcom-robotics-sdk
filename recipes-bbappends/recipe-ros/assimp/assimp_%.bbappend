CXXFLAGS += " -Wno-error=unused-but-set-variable"
