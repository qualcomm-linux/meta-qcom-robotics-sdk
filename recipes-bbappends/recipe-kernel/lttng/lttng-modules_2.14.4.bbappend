FILESEXTRAPATHS:prepend := "${THISDIR}/lttng-modules:"

SRC_URI += " \
    file://0001-soc-dapm-move-struct-snd_soc_dapm_context.patch \
"