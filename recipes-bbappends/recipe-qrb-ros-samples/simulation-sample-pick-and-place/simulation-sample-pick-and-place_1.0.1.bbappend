FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-simulation_sample_pick_and_place-cmake-cleanup.patch"
